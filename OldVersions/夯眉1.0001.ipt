# Autodesk Inventor part: 본체1
## iProperties
Created: 2015-03
Part Number: 본체1
Document SubType Name: Modeling
Designer: 102-02
Density: 1 g/cm^3
Author: 102-02
